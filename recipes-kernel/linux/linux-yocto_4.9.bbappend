
#COMPATIBLE_MACHINE = "(ess-ifc1410-64b|ess-ifc1410-32b)"

KERNEL_DEVICETREE_ess-ifc1410-64b = "${MACHINE}.dtb"

KERNEL_DEVICETREE_ess-ifc1410-32b = "${MACHINE}.dtb"

# Functionality flags
#KERNEL_EXTRA_FEATURES ?= " "
#KERNEL_FEATURES_append = " ${KERNEL_EXTRA_FEATURES}"
#KERNEL_FEATURES_append_ess-ifc1410-64b = " "
#KERNEL_FEATURES_append_ess-ifc1410-32b = " "
