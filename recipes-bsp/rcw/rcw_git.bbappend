EXTRA_OEMAKE = "PYTHON=python BOARDS=t2080qds DESTDIR=${D}/boot/rcw/"
#
